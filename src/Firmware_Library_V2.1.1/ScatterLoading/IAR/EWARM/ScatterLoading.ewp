# IAR project ScatterLoading.ewp, settings and files
configuration GD32F330 (ARM, debug)
  General.OGChipSelectEditMenu: GD32F330x8 GD GD32F330x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F3X0; GD32F330
  ICCARM.CCIncludePath2: ..\..\..\Firmware\CMSIS; ..\..\..\Firmware\CMSIS\GD\GD32F3x0; ..\..\..\Firmware\GD32F3x0_standard_peripheral\Include; ..\..\..\Utilities; ..; ..\..\..\Firmware\CMSIS\GD\GD32F3x0\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ScatterLoading.srec
  ILINK.IlinkOutputFile: ScatterLoading.out
  ILINK.IlinkIcfFile: ..\gd32f3x0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32F350 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F350xB GD GD32F350xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F3X0; GD32F350
  ICCARM.CCIncludePath2: ..\..\Firmware\CMSIS; ..\..\Firmware\CMSIS\GD\GD32F3x0\Include; ..\..\..\Firmware\GD32F3x0_standard_peripheral\Include; ..\..\..\Utilities; ..; ..\..\..\Firmware\CMSIS\GD\GD32F3x0\Include
  ILINK.IlinkOutputFile: Project.out
  group Application
    ../: const-data.c hw_config.c main.c
  group CMSIS
    ../../../Firmware/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group GD32F3x0_EVAL
    ../../../Utilities/: gd32f350r_eval.c
  group GD32F3x0_Peripherals
    ../../../Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group Startup
    ../../../Firmware/CMSIS/GD/GD32F3x0/Source/IAR/: startup_gd32f3x0.s
